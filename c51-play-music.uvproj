# Keil uVision project c51-play-music.uvproj, settings and files
target beep (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: beep +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./beep/: main.c music_data.c music_data.h
